*HEADING
Aero bounded structural study; SI
*NODE
1,0.012,0,0
2,0.012,0,0.037
3,0.012,0,0.043
4,0.012,0,0.08
5,0.0116189500386,0.003,0.04
6,0.01,0,0
7,0.01,0,0.043
8,0.01,0,0.037
9,0.00953939201417,0.003,0.04
10,0.01,0,0.08
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*ELEMENT,TYPE=C3D10,ELSET=SOLID
16891,21010,21012,3672,21011,32959,33342,33343,32952,32960,33344
16892,19629,1990,19389,1989,33345,33346,27139,33347,12311,33348
16893,3692,2940,4014,33184,16715,14106,10494,33349,33351,33350
16894,21159,19352,19354,2462,26955,26953,26956,33352,33354,33353
16895,18707,18709,18708,2958,23705,23704,23697,33355,33357,33356
16896,3641,1527,19380,19379,9771,33358,33359,33360,33361,26398
16897,974,21149,19653,33304,33362,27516,33363,33364,33366,33365
16898,20827,20321,21361,33337,31653,31651,31654,33367,33369,33368
16899,20342,753,780,19944,33370,6118,33371,26168,33373,33372
16900,19197,759,19194,21105,33374,33375,26162,26163,33376,26164
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*NSET,NSET=ALLN
1
2
3
4
5
6
7
8
9
10
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*NSET,NSET=SUPPORT
1
6
245
246
247
248
249
250
251
252
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*MATERIAL,NAME=ALLOY
*ELASTIC
70000000000.0,0.3
*DENSITY
2700.0
*EXPANSION,ZERO=273.15
2.3e-05
*SOLID SECTION,ELSET=SOLID,MATERIAL=ALLOY
*BOUNDARY
1,3,3,0.0
6,3,3,0.0
245,3,3,0.0
246,3,3,0.0
247,3,3,0.0
248,3,3,0.0
249,3,3,0.0
250,3,3,0.0
251,3,3,0.0
252,3,3,0.0
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*STEP
*STATIC
*DLOAD
16891,P2,1000000
16894,P1,1000000
16895,P1,1000000
16898,P1,1000000
16900,P4,1000000
16902,P1,1000000
16915,P1,1000000
16916,P3,1000000
16922,P4,1000000
16924,P1,1000000
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*NODE FILE
U,RF,NT
*EL FILE
S,E
*NODE PRINT,NSET=ALLN
U
*NODE PRINT,NSET=SUPPORT,TOTALS=YES
RF
*EL PRINT,ELSET=SOLID
S,E,ENER
*END STEP
