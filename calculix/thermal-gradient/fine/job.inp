*HEADING
Aero bounded structural study; SI
*NODE
1,0,0,0
2,0,0,0.01
3,0,0.01,0
4,0,0.01,0.01
5,0.1,0,0
6,0.1,0,0.01
7,0.1,0.01,0
8,0.1,0.01,0.01
9,0,0,0.0025
10,0,0,0.005
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*ELEMENT,TYPE=C3D10,ELSET=SOLID
1959,614,3597,3679,3690,3726,3727,3728,3729,3731,3730
1960,3520,3555,3537,3608,3732,3733,3734,3735,3737,3736
1961,3537,3555,3520,3589,3733,3732,3734,3738,3740,3739
1962,3554,3570,3524,3571,3741,3742,3743,3744,3746,3745
1963,3532,3570,3554,3571,3747,3741,3748,3749,3746,3744
1964,3555,3608,3520,3627,3737,3735,3732,3750,3752,3751
1965,624,652,528,3536,993,992,897,3753,3755,3754
1966,2796,528,2899,3536,3756,3757,3036,3758,3754,3759
1967,614,3679,3556,3690,3728,3760,3761,3729,3730,3762
1968,2868,3565,3542,3614,3763,3764,3765,3766,3768,3767
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*NSET,NSET=ALLN
1
2
3
4
5
6
7
8
9
10
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*NSET,NSET=SUPPORT
1
2
3
4
5
6
7
8
9
10
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*MATERIAL,NAME=ALLOY
*ELASTIC
70000000000.0,0.3
*DENSITY
2700.0
*EXPANSION,ZERO=273.15
2.3e-05
*SOLID SECTION,ELSET=SOLID,MATERIAL=ALLOY
*BOUNDARY
1,1,1,0.0
1,2,2,0.0
1,3,3,0.0
2,1,1,0.0
2,2,2,0.0
3,1,1,0.0
3,3,3,0.0
4,1,1,0.0
5,1,1,0.0
5,2,2,0.0
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*INITIAL CONDITIONS,TYPE=TEMPERATURE
ALLN,273.15
*STEP
*STATIC
*TEMPERATURE
1,323.15
2,323.15
3,323.15
4,323.15
5,353.15
6,353.15
7,353.15
8,353.15
9,323.15
10,323.15
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*NODE FILE
U,RF,NT
*EL FILE
S,E
*NODE PRINT,NSET=ALLN
U
*NODE PRINT,NSET=SUPPORT,TOTALS=YES
RF
*EL PRINT,ELSET=SOLID
S,E,ENER
*END STEP
