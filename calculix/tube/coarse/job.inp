*HEADING
Aero bounded structural study; SI
*NODE
1,0.01,0,0
2,0.012,0,0
3,0.012,0.08,0
4,0.01,0.08,0
5,0.011,0,0
6,0.0105,0,0
7,0.0115,0,0
8,0.012,0.00333333333333,0
9,0.012,0.00666666666667,0
10,0.012,0.01,0
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*ELEMENT,TYPE=CAX8,ELSET=SOLID
57,1,5,105,80,6,128,129,104
58,80,105,106,79,129,130,131,103
59,79,106,107,78,131,132,133,102
60,78,107,108,77,133,134,135,101
61,77,108,109,76,135,136,137,100
62,76,109,110,75,137,138,139,99
63,75,110,111,74,139,140,141,98
64,74,111,112,73,141,142,143,97
65,73,112,113,72,143,144,145,96
66,72,113,114,71,145,146,147,95
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*NSET,NSET=ALLN
1
2
3
4
5
6
7
8
9
10
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*NSET,NSET=SUPPORT
1
2
5
6
7
*MATERIAL,NAME=ALLOY
*ELASTIC
70000000000.0,0.3
*DENSITY
2700.0
*EXPANSION,ZERO=273.15
2.3e-05
*SOLID SECTION,ELSET=SOLID,MATERIAL=ALLOY
*BOUNDARY
1,2,2,0.0
2,2,2,0.0
5,2,2,0.0
6,2,2,0.0
7,2,2,0.0
*STEP
*STATIC
*DLOAD
57,P4,1000000
58,P4,1000000
59,P4,1000000
60,P4,1000000
61,P4,1000000
62,P4,1000000
63,P4,1000000
64,P4,1000000
65,P4,1000000
66,P4,1000000
67,P4,1000000
68,P4,1000000
69,P4,1000000
70,P4,1000000
71,P4,1000000
72,P4,1000000
73,P4,1000000
74,P4,1000000
75,P4,1000000
76,P4,1000000
77,P4,1000000
78,P4,1000000
79,P4,1000000
80,P4,1000000
*NODE FILE
U,RF,NT
*EL FILE
S,E
*NODE PRINT,NSET=ALLN
U
*NODE PRINT,NSET=SUPPORT,TOTALS=YES
RF
*EL PRINT,ELSET=SOLID
S,E,ENER
*END STEP
