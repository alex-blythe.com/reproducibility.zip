*HEADING
Aero bounded structural study; SI
*NODE
1,0.01,0,0
2,0.012,0,0
3,0.012,0.08,0
4,0.01,0.08,0
5,0.0106666666667,0,0
6,0.0113333333333,0,0
7,0.0103333333333,0,0
8,0.011,0,0
9,0.0116666666667,0,0
10,0.012,0.00222222222222,0
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*ELEMENT,TYPE=CAX8,ELSET=SOLID
83,1,5,157,120,7,227,228,156
84,120,157,158,119,228,229,230,155
85,119,158,159,118,230,231,232,154
86,118,159,160,117,232,233,234,153
87,117,160,161,116,234,235,236,152
88,116,161,162,115,236,237,238,151
89,115,162,163,114,238,239,240,150
90,114,163,164,113,240,241,242,149
91,113,164,165,112,242,243,244,148
92,112,165,166,111,244,245,246,147
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*NSET,NSET=ALLN
1
2
3
4
5
6
7
8
9
10
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*NSET,NSET=SUPPORT
1
2
5
6
7
8
9
*MATERIAL,NAME=ALLOY
*ELASTIC
70000000000.0,0.3
*DENSITY
2700.0
*EXPANSION,ZERO=273.15
2.3e-05
*SOLID SECTION,ELSET=SOLID,MATERIAL=ALLOY
*BOUNDARY
1,2,2,0.0
2,2,2,0.0
5,2,2,0.0
6,2,2,0.0
7,2,2,0.0
8,2,2,0.0
9,2,2,0.0
*STEP
*STATIC
*DLOAD
83,P4,1000000
84,P4,1000000
85,P4,1000000
86,P4,1000000
87,P4,1000000
88,P4,1000000
89,P4,1000000
90,P4,1000000
91,P4,1000000
92,P4,1000000
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*NODE FILE
U,RF,NT
*EL FILE
S,E
*NODE PRINT,NSET=ALLN
U
*NODE PRINT,NSET=SUPPORT,TOTALS=YES
RF
*EL PRINT,ELSET=SOLID
S,E,ENER
*END STEP
