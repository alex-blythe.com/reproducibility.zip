*HEADING
Aero bounded structural study; SI
*NODE
1,0.01,0,0
2,0.012,0,0
3,0.012,0.08,0
4,0.01,0.08,0
5,0.0105,0,0
6,0.011,0,0
7,0.0115,0,0
8,0.01025,0,0
9,0.01075,0,0
10,0.01125,0,0
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*ELEMENT,TYPE=CAX8,ELSET=SOLID
109,1,5,209,160,8,350,351,208
110,160,209,210,159,351,352,353,207
111,159,210,211,158,353,354,355,206
112,158,211,212,157,355,356,357,205
113,157,212,213,156,357,358,359,204
114,156,213,214,155,359,360,361,203
115,155,214,215,154,361,362,363,202
116,154,215,216,153,363,364,365,201
117,153,216,217,152,365,366,367,200
118,152,217,218,151,367,368,369,199
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*NSET,NSET=ALLN
1
2
3
4
5
6
7
8
9
10
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*NSET,NSET=SUPPORT
1
2
5
6
7
8
9
10
11
*MATERIAL,NAME=ALLOY
*ELASTIC
70000000000.0,0.3
*DENSITY
2700.0
*EXPANSION,ZERO=273.15
2.3e-05
*SOLID SECTION,ELSET=SOLID,MATERIAL=ALLOY
*BOUNDARY
1,2,2,0.0
2,2,2,0.0
5,2,2,0.0
6,2,2,0.0
7,2,2,0.0
8,2,2,0.0
9,2,2,0.0
10,2,2,0.0
11,2,2,0.0
*STEP
*STATIC
*DLOAD
109,P4,1000000
110,P4,1000000
111,P4,1000000
112,P4,1000000
113,P4,1000000
114,P4,1000000
115,P4,1000000
116,P4,1000000
117,P4,1000000
118,P4,1000000
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*NODE FILE
U,RF,NT
*EL FILE
S,E
*NODE PRINT,NSET=ALLN
U
*NODE PRINT,NSET=SUPPORT,TOTALS=YES
RF
*EL PRINT,ELSET=SOLID
S,E,ENER
*END STEP
